# Keil uVision project STM32Oscilloscope.uvprojx, settings and files
target STM32Oscilloscope (ARM-ADS)
  device: STM32F407VGT6 STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CLOCK(168000000) CPUTYPE("Cortex-M4") FPU2("SP-DP") ELITTLE
  output: STM32Oscilloscope +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, ARM_MATH_CM4, __FPU_PRESENT=1U, HSE_VALUE=8000000U
  c misc: --c99 --gnu
  c include: ..\Core\Inc;..\BSP\Inc;..\App\Inc;..\LCD\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F407VGTx.sct
  group Application/User
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    ./: retarget.c
  group BSP
    ../BSP/Src/: bsp_adc.c bsp_lcd.c bsp_encoder.c bsp_button.c bsp_timer.c
  group LCD
    ../LCD/Src/: ili9341.c lcd_font.c lcd_graphic.c
  group App
    ../App/Src/: oscilloscope.c waveform.c fft_analyzer.c ui_menu.c ui_state_machine.c frequency_counter.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS-DSP
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_fill_f32.c arm_copy_f32.c arm_float_to_q31.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_sqrt_q31.c
  group MDK-ARM
    ./: startup_stm32f407xx.s
